# Keil uVision project project.uvprojx, settings and files
target sapu-fixwing (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: sapu-fixwing
  AfterMake: fromelf --bin !L --output .\build\keil\EXC\sapu-fixwing.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, USE_FULL_LL_DRIVER, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, STM32H743xx, DATA_IN_D2_SRAM, RT_USING_LIBC, USE_HAL_DRIVER
  c include: packages\CMSIS-DSP-latest\Include\dsp;..\..\rt-thread\components\drivers\include;..\..\lib\mavlink\v2.0\fmt;..\..\rt-thread\libcpu\arm\cortex-m7;..\..\model\control\fw_controller\lib;.;..\..\rt-thread\components\libc\posix\io\eventfd;..\..\rt-thread\components\libc\posix\ipc;..\..\rt-thread\components\utilities\ulog\backend;..\..\model\control\fw_controller;..\..\model\plant\fixwing\lib;..\..\rt-thread\components\drivers\include;..\..\rt-thread\libcpu\arm\common;board\CubeMX_Config\Core\Inc;..\..\rt-thread\bsp\stm32\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\rt-thread\components\drivers\include;..\..\task\logger;packages\CMSIS-DSP-latest\PrivateInclude;..\..\rt-thread\components\drivers\phy;..\..\rt-thread\include;..\..\model\ins\external_ins\lib;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\sdio\sdhci\include;..\..\rt-thread\components\drivers\include;..\..\lib\mavlink\v2.0;..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\rt-thread\components\libc\posix\io\epoll;..\..\rt-thread\components\drivers\ktime\inc;packages\CMSIS-DSP-latest\Include;..\..\rt-thread\components\drivers\include;..\..\extdev;..\..;applications;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\libc\compilers\common\extension;..\..\model\fms\fw_fms;board;..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers\CMSIS\Include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;packages\optparse-latest;..\..\rt-thread\components\drivers\spi;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\dfs\dfs_v1\include;..\..\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;..\..\rt-thread\components\finsh;..\..\model\ins\external_ins;..\..\model\plant\fixwing;..\..\rt-thread\components\libc\posix\io\poll;..\..\rt-thread\bsp\stm32\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\rt-thread\components\libc\posix\delay;..\..\rt-thread\components\drivers\smp_call;..\..\rt-thread\components\legacy\dfs;..\..\rt-thread\components\utilities\ulog;..\..\rt-thread\components\drivers\ktime;..\..\rt-thread\bsp\stm32\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\rt-thread\components\libc\compilers\common\include;..\..\rt-thread\components\legacy;..\..\model\fms\fw_fms\lib;..\..\task\comm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: rgb.c sd_hotplug.c
    ../../task/comm/: mavgcs.c mavobc.c task_comm.c
    ../../task/logger/: task_logger.c
    ../../task/status/: task_status.c
    ../../task/vehicle/fixwing/: task_vehicle.c
  group Board_Drivers
    board/: drv_spi.c drv_systick.c drv_adc.c drv_sdmmc.c board.c drv_pwm.c drv_gpio.c drv_soft_i2c.c drv_usart_v2.c drv_can.c
    ../../rt-thread/bsp/stm32/libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    board/CubeMX_Config/Core/Src/: main.c stm32h7xx_hal_msp.c system_stm32h7xx.c
  group CMSIS_DSP
    packages/CMSIS-DSP-latest/Source/BasicMathFunctions/: BasicMathFunctionsF16.c BasicMathFunctions.c
    packages/CMSIS-DSP-latest/Source/CommonTables/: CommonTablesF16.c CommonTables.c
    packages/CMSIS-DSP-latest/Source/FastMathFunctions/: FastMathFunctionsF16.c FastMathFunctions.c
  group Compiler
    ../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../rt-thread/components/drivers/can/: dev_can.c
    ../../rt-thread/components/drivers/core/: device.c
    ../../rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/misc/: adc.c
    ../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../rt-thread/components/drivers/rtc/: dev_rtc.c dev_soft_rtc.c
    ../../rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../rt-thread/components/drivers/serial/: dev_serial_v2.c
    ../../rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
  group extDeviceDrivers
    ../../extdev/: dev_actuator.c dev_gps.c dev_rc_ppm.c dev_airspeed.c dev_rc.c dev_accel.c dev_rc_sbus.c dev_barometer.c dev_gyro.c dev_mag.c
  group extDriver
    ../../extdriver/imu/: mpu6000.c icm20600.c icm20948.c bmi055.c icm42688p.c icm20689.c l3gd20h.c bmi088.c lsm303d.c icm20649.c
    ../../extdriver/mag/: rm3100.c bmm150.c
    ../../extdriver/gps/: gps_ubx.c ublox.c
  group Filesystem
    ../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../rt-thread/components/finsh/: cmd.c msh.c shell.c msh_parse.c msh_file.c
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../rt-thread/src/klibc/: kstdio.c kerrno.c rt_vsscanf.c rt_vsnprintf_tiny.c kstring.c
  group ktime
    ../../rt-thread/components/drivers/ktime/src/: cputimer.c boottime.c hrtimer.c
  group Legacy
    ../../rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group MAVLink
    ../../module/mavproxy/: mavlink_rtcm.c mavproxy.c mavproxy_dev.c mavlink_status.c mavproxy_monitor.c mavlink_console.c mavproxy_config.c mavlink_param.c mavlink_mission.c mavproxy_cmd.c
  group Model-Controller-FW
    ../../model/control/fw_controller/lib/: Controller_data.c Controller.c
    ../../model/control/fw_controller/: control_interface.c
  group Model-FMS-FW
    ../../model/fms/fw_fms/lib/: FMS_data.c FMS.c
    ../../model/fms/fw_fms/: fms_interface.c
  group Model-INS-EXT
    ../../model/ins/external_ins/: ins_interface.c
  group Model-Plant-FW
    ../../model/plant/fixwing/lib/: rt_look1d.c Plant.c rt_look2d_normal.c Plant_data.c rt_look.c
    ../../model/plant/fixwing/: plant_interface.c
  group optparse
    packages/optparse-latest/: optparse.c
  group POSIX
    ../../rt-thread/components/libc/posix/delay/: delay.c
  group Sensor-Hub
    ../../module/ipc/: uMCN.c cmd_mcn.c
    ../../module/sensor/: sensor_gps.c sensor_baro.c sensor_imu.c sensor_hub.c sensor_mag.c sensor_airspeed.c
    ../../module/pmu/: power_manage.c
  group STM32_HAL
    ../../rt-thread/bsp/stm32/libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sd_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_eth.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_crc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_eth_ex.c stm32h7xx_ll_usart.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_cryp.c stm32h7xx_ll_rcc.c stm32h7xx_hal_exti.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_pssi.c stm32h7xx_ll_bdma.c stm32h7xx_hal_cryp_ex.c stm32h7xx_ll_pwr.c stm32h7xx_hal_hsem.c stm32h7xx_hal_pcd.c stm32h7xx_hal_smbus_ex.c stm32h7xx_ll_exti.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dac_ex.c stm32h7xx_ll_mdma.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_adc.c stm32h7xx_ll_adc.c stm32h7xx_hal_iwdg.c stm32h7xx_ll_usb.c stm32h7xx_hal_mmc.c stm32h7xx_hal_dcmi.c stm32h7xx_ll_rtc.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_spi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_cec.c stm32h7xx_ll_fmac.c stm32h7xx_hal_flash.c stm32h7xx_ll_crs.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_ll_spi.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_hrtim.c stm32h7xx_hal_comp.c stm32h7xx_ll_i2c.c stm32h7xx_hal_fmac.c stm32h7xx_hal_nand.c stm32h7xx_ll_fmc.c stm32h7xx_hal_dma.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_lptim.c stm32h7xx_hal_hcd.c stm32h7xx_hal_rcc.c stm32h7xx_ll_gpio.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_tim.c stm32h7xx_ll_utils.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_rtc.c stm32h7xx_ll_cordic.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_rng.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_opamp.c stm32h7xx_hal_i2c.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_dac.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_usart.c stm32h7xx_ll_swpmi.c stm32h7xx_hal_gpio.c stm32h7xx_ll_comp.c stm32h7xx_hal_sd.c stm32h7xx_ll_crc.c stm32h7xx_hal_dsi.c stm32h7xx_hal_hash.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_wwdg.c stm32h7xx_hal.c stm32h7xx_ll_tim.c stm32h7xx_hal_lptim.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_ll_dma.c stm32h7xx_hal_dts.c stm32h7xx_ll_opamp.c stm32h7xx_hal_i2s.c stm32h7xx_hal_opamp_ex.c stm32h7xx_ll_dma2d.c stm32h7xx_hal_adc_ex.c stm32h7xx_ll_lpuart.c stm32h7xx_hal_mdios.c stm32h7xx_hal_sai.c stm32h7xx_hal_sdram.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_irda.c
  group Tool-Files
    ../../module/toml/: toml.c toml_util.c
    ../../module/file_manager/: yxml.c file_manager.c file_ex_ops.c
    ../../module/log/: boot_log.c mlog.c
  group Tool-Math
    ../../module/filter/: butter.c
    ../../module/math/: quaternion.c conversion.c rotation.c light_matrix.c ap_math.c
  group Tool-Param
    ../../module/calibration/: calibration_param.c rtGetInf.c rtGetNaN.c rt_nonfinite.c calibration.c
    ../../module/param/: sys_param.c param.c rc_param.c
  group Tool-System-IO
    ../../module/sysio/: actuator_config.c actuator_cmd.c auto_cmd.c gcs_cmd.c mission_data.c pilot_cmd.c pilot_cmd_config.c
    ../../module/console/: console.c
  group Utilities
    ../../rt-thread/components/utilities/ulog/backend/: file_be.c console_be.c
    ../../rt-thread/components/utilities/ulog/: ulog.c
